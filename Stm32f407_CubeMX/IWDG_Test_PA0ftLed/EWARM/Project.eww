<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IWDG_Test_PA0ftLed.ewp</path>
  </project>
  <batchBuild />
</workspace>
